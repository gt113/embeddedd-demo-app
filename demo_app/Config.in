## demo_app/Config.in
```kconfig
config BR2_PACKAGE_DEMO_APP
    bool "demo_app"
    help
      Very simple demo application for embedded Linux using Buildroot.
```
